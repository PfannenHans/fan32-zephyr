## boards/pfannenhans/fan32/board.yml
```yaml
board:
  name: fan32
  full_name: Fan32
  vendor: pfannenhans
  socs:
  - name: esp32c3
```
